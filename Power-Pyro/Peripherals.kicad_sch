File: Power-Pyro/Peripherals.kicad_sch (KiCad schematic)
At the start: 5 parts, among them J5 Conn_02x06_Odd_Even

Commit message: 🔌
Other:
- moved on the sheet: H1, H2, H3, H4, J5
